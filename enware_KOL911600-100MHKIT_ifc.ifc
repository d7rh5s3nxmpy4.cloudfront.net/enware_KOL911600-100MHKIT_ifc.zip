Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2022-01-06T15:25:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 06 15:25:23 2022 * Host: DESKTOP-5NN4IDP * Database: C:\Users\PC-041\AppData\Local\Temp\{104059D0-0829-4E4E-8A9F-A8CACB1724D5}\ifc * Database version: 5507 * Database creation date: Thu Jan 06 15:25:22 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 06 15:25:22 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 06 15:25:23 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: \\192.168.1.99\Vol-2-New\MEP 2022\Mark N\Project Fixture\Working\KOL911600-100MHKIT\KOL911600-100MHKIT.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: KOL911600-100MHKIT, KOL911600-100MHKIT:KOL911600-100MHKIT:4822
In: Level 1
Material: Default
Pset_ManufacturerTypeInformation - Manufacturer: Basin - KOL911600-100, Shroud - KOL97200, Plug & Waste - IFO3240, Standard Trap - KOL15600
Pset_DistributionFlowElementCommon - Reference: KOL911600-100MHKIT
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.700005 m2; Volume: 0.0325562 m3; Depth: 410 mm; Height: 160 mm; Still Height: 850 mm; Width: 600 mm
Identity Data - Mark: 2; Description: Mental Health Kit with 600mm Kolo Rekord Round Basin, Shroud, Wate and P-Trap; Manufacturer: Basin - KOL911600-100, Shroud - KOL97200, Plug & Waste - IFO3240, Standard Trap - KOL15600; Model: KOL911600-100MHKIT; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: KOL911600-100MHKIT; URL: website link: www.enware.com.au
Other - Category: Plumbing Fixtures; Family: KOL911600-100MHKIT: KOL911600-100MHKIT; Family and Type: KOL911600-100MHKIT: KOL911600-100MHKIT; Type: KOL911600-100MHKIT: KOL911600-100MHKIT; Type Id: KOL911600-100MHKIT: KOL911600-100MHKIT; Family Name: KOL911600-100MHKIT
Phasing - Phase Created: New Construction
